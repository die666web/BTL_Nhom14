# Keil uVision project Bootloader.uvprojx, settings and files
target STM32F103C8_Bootloader (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x2000) CLOCK(8000000) CPUTYPE("Cortex-M3") ELITTLE
  output: bootloader +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c misc: -std=c11 -Wall -Wextra -Werror -ffunction-sections -fdata-sections
  c include: ..\bootloader\inc;..\bsp;..\common\ota_frame
  scatter file: .\Bootloader.sct
  link misc: --entry=Reset_Handler --strict
  group Core
    ../bootloader/src/: main.c
    ../: startup.c
  group Bootloader
    ../bootloader/src/: boot_port.c boot_flash.c boot_validate.c boot_protocol.c boot_jump.c
  group Common
    ../common/ota_frame/: ota_frame.c
