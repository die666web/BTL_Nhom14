# Keil uVision project MCU_Project.uvprojx, settings and files
target STM32F103C8_App (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CLOCK(8000000) CPUTYPE("Cortex-M3") ELITTLE
  output: firmware +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c misc: -std=c11 -Wall -Wextra -Werror -ffunction-sections -fdata-sections
  c include: ..;..\bsp;..\hal\inc;..\app\inc;..\middlewares\FreeRTOS-Kernel\include;..\middlewares\FreeRTOS-Kernel\portable\GCC\ARM_CM3
  scatter file: .\STM32F103C8.sct
  link misc: --entry=Reset_Handler --strict
  group Core
    ../: main.c startup.c
  group BSP
    ../bsp/: bsp.c
  group HAL
    ../hal/src/: button.c hal_gpio.c hal_i2c.c hal_rcc.c hal_uart.c ina219.c oled.c relay.c
  group Application
    ../app/src/: app_ipc.c rtos_hooks.c task_comm.c task_control.c task_display.c task_measure.c
  group FreeRTOS
    ../middlewares/FreeRTOS-Kernel/: tasks.c list.c queue.c timers.c event_groups.c stream_buffer.c
    ../middlewares/FreeRTOS-Kernel/portable/GCC/ARM_CM3/: port.c
    ../middlewares/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
